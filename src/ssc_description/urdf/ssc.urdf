Commit message: create gps_utm frame

File: src/ssc_description/urdf/ssc.urdf (robot description, URDF)
Before this commit: robot ssc, 2 links, 1 joints
Links:
- link base_link: mass 1000 -> None
